<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MP-II_ver2.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
